# Keil uVision project lib_lpc_boards_18xx_43xx.uvproj, settings and files
target ngx_xplorer_4330 (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: lib_4330 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\lpc_ip;..\..\lpc_chip\chip_18xx_43xx;..\board_common;.\ngx_xplorer_18304330;.\ngx_xplorer_18304330\ngx_xplorer_4330;..\..\lpc_chip\chip_common;..\..\..\CMSIS
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group ip
    ../../lpc_ip/: adc_001.c atimer_001.c emc_001.c enet_001.c fpu_init.c gpdma_001.c gpioint_001.c gpiopinint_001.c i2c_001.c i2s_001.c lcd_001.c ritimer_001.c rtc_001.c sdmmc_001.c ssp_001.c timer_001.c usart_001.c dac_001.c sct_001.c ccan_001.c wwdt_001.c eeprom_002.c
  group chip_18xx43xx
    ../../lpc_chip/chip_18xx_43xx/: adc_18xx_43xx.c aes_18xx_43xx.c atimer_18xx_43xx.c clock_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c gpdma_18xx_43xx.c gpio_18xx_43xx.c i2c_18xx_43xx.c i2s_18xx_43xx.c lcd_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c sdmmc_18xx_43xx.c ssp_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c rgu_18xx_43xx.c scu_18xx_43xx.c dac_18xx_43xx.c ccan_18xx_43xx.c pmc_18xx_43xx.c timer_18xx_43xx.c sct_18xx_43xx.c otp_18xx_43xx.c sct_18xx_43xx.c eeprom_18xx_43xx.c sdif_18xx_43xx.c
    ../../lpc_chip/chip_common/: mem_tests.c ring_buffer.c
  group board_ngx_xplorer_18304330
    ./ngx_xplorer_18304330/: board_ngx_xplorer_18304330.c sysinit_ngx_xplorer_18304330.c
    ../board_common/: uda1380.c
target ngx_xplorer_4330_m0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: board_ngx_xplorer_4330_m0 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: as above
