# Keil uVision project keilusblib.uvproj, settings and files
target Keil USB library (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: keilusblib (library)
  c flags: Optim=1
  c define: CORE_M4 USE_USB0
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_LPC43xx.s
  group Source
    ./: adcuser.c cdcuser.c mscuser.c usbcore.c usbdesc.c usbhw.c usbuser.c vcomdemo.c
  group Include
    ./: adcuser.h audio.h cdc.h cdcuser.h lpc43xx_libcfg.h msc.h mscuser.h serial.h usb.h usbaudio.h usbcfg.h usbcore.h usbdesc.h usbhw.h usbuser.h vcomdemo.h
