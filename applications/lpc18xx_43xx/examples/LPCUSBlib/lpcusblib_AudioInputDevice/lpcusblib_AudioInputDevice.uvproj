# Keil uVision project lpcusblib_AudioInputDevice.uvproj, settings and files
target ngx_4330_ram (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: usbaudio_dev +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC43XX__ CORE_M4 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../LPCUSBlib/lpcusblib_AudioInputDevice/: AudioInput.c Descriptors.c
    ../../../../LPCUSBlib/lpcusblib_AudioInputDevice/Lib/: UsbRom.c
    ../startup_code/: keil_startup_lpc18xx43xx.s
  group lib
    ../../../../LPCUSBlib/lpcusblib_AudioInputDevice/debug_lib/: lib_4330.lib
    ../../../../LPCUSBlib/lpcusblib_AudioInputDevice/debug_usb/: usb_43xx.lib
