# Keil uVision project freertos_blinky.uvproj, settings and files
target spifi_ngx_xplorer_4330 (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: freertos_blinky_spifi_ngx_xplorer_4330
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\freertos_blinky
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./: freertos_blinky.c
    ../startup_code/: keil_freertos_startup_lpc18xx43xx.s
  group lib
    ../../../../../lib/: lib_4330.lib
  group FreeRTOS_43xx
    ../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS
    ../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../software/freertos/freertos/Source/: croutine.c queue.c list.c tasks.c timers.c
    ../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
