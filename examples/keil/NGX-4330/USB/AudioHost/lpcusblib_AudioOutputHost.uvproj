# Keil uVision project lpcusblib_AudioOutputHost.uvproj, settings and files
target spifi_ngx_xplorer_4330 (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: 4330-audio-host +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC43XX__ CORE_M4 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common
  asm define: NO_CRP
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../startup_code/: keil_startup_lpc18xx43xx.s
    ./: AudioOutputHost.c
  group lib
    ../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/keil_output/LPCUSBlib_LPC43xx_Host/: LPCUSBlib_LPC43xx_Host.lib
