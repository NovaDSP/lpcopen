# Keil uVision project ngx-4330-audio.uvproj, settings and files
target ngx_4330_ram (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: usbaudio_dev +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __LPC43XX__ CORE_M4 USB_DEVICE_ONLY NO_LIMITED_CONTROLLER_CONNECT
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;.\freertos\include;.\freertos;.
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./: AudioInput.c Descriptors.c UsbRom.c keil_startup_lpc18xx43xx.s AudioInput.h Descriptors.h UsbRom.h config.h
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/ngx_xplorer_18304330/ngx_xplorer_4330/: sys_config.h
  group lpc_lib
    ../../../../../software/lpc_core/lpc_ip/: adc_001.c atimer_001.c eeprom_002.c emc_001.c enet_001.c fpu_init.c gpdma_001.c gpio_003.c gpiogrpint_001.c gpioint_001.c gpiopinint_001.c i2c_001.c i2s_001.c lcd_001.c ritimer_001.c rtc_001.c sct_001.c sdc_001.c sdmmc_001.c spi_002.c ssp_001.c timer_001.c usart_001.c wwdt_001.c
    ../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/: adc_18xx_43xx.c aes_18xx_43xx.c atimer_18xx_43xx.c clock_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c gpdma_18xx_43xx.c gpio_18xx_43xx.c i2c_18xx_43xx.c i2s_18xx_43xx.c lcd_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c sdmmc_18xx_43xx.c ssp_18xx_43xx.c timer_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c sdif_18xx_43xx.c sct_18xx_43xx.c scu_18xx_43xx.c rgu_18xx_43xx.c
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/ngx_xplorer_18304330/: board_ngx_xplorer_18304330.c sysinit_ngx_xplorer_18304330.c
    ../../../../../software/lpc_core/lpc_board/board_common/: uda1380.c
  group usb_lib
    ../../../../../software/LPCUSBLib/Drivers/USB/Class/Common/: AudioClassCommon.h
    ../../../../../software/LPCUSBLib/Drivers/USB/Class/Device/: AudioClassDevice.c AudioClassDevice.h
    ../../../../../software/LPCUSBLib/Drivers/USB/Core/: ConfigDescriptor.c Device.c DeviceStandardReq.c Endpoint.c EndpointStream.c Events.c Host.c HostStandardReq.c Pipe.c PipeStream.c USBController.c USBMemory.c USBTask.c
    ../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/: HCD.c
    ../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/OHCI/: OHCI.c
    ../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/EHCI/: EHCI.c
    ../../../../../software/LPCUSBLib/Drivers/USB/Core/DCD/USBRom/: usbd_adcuser.c usbd_cdc.c usbd_hid.c usbd_msc.c usbd_rom.c
    ../../../../../software/LPCUSBLib/Drivers/USB/Core/DCD/: EndpointCommon.h
    ../../../../../software/LPCUSBLib/: LPCUSBlibConfig.h
    ../../../../../software/LPCUSBLib/Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c
    ../../../../../software/LPCUSBLib/Drivers/USB/Core/DCD/LPC18XX/: Endpoint_LPC18xx.c
  group linker
    ./debug/: usbaudio_dev.sct
  group FreeRTOS
    ./freertos/: heap_3.c list.c queue.c tasks.c timers.c port.c keil_freertos_startup_lpc18xx43xx.s FreeRTOSCommonHooks.c
target ngx_4357_ram (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: usbaudio_dev +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _USE_4357 __LPC43XX__ CORE_M4 USB_DEVICE_ONLY NO_LIMITED_CONTROLLER_CONNECT
  c misc: --gnu --c99
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
